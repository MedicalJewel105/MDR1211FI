# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.2.0i, Drivers:I2C 2.2.0i, Drivers:PORT 2.2.0i, Drivers:POWER 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:TIMER 2.2.0i, Drivers:UART 2.2.0i
